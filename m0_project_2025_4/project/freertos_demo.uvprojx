# Keil uVision project freertos_demo.uvprojx, settings and files
target freertos_demo (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos_demo +hex
  BeforeMake: cmd.exe /C "$P../tools/syscfg.bat '$P' blink_led.syscfg"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\project;..\source;..\source\third_party\CMSIS\Core\Include;..\kernel\freertos\Source\include;..\kernel\freertos\Source\portable\GCC\ARM_CM0;..\kernel\freertos\builds\LP_MSPM0G3507\release;..\drivers;..\hardware\bsp;..\utils;..\fonts;..\app;..\user
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: ../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a ../kernel/freertos/builds/LP_MSPM0G3507/release/keil/Objects/freertos_builds_LP_MSPM0G3507_release_keil.lib
  group project
    ./: ti_msp_dl_config.c startup_mspm0g350x_uvision.s freertos_demo.syscfg
  group utils
    ../utils/: delay.c log.c
  group user
    ../user/: main.c
  group drivers
    ../drivers/: motor.c oled.c pca9555.c
  group hardware/bsp
    ../hardware/bsp/: software_i2c.c uart.c spi.c
  group fonts
    ../fonts/: oled_data.c
  group app
    ../app/: gray_detection.c motor_controller.c
  group readme
    ../../: README.md
