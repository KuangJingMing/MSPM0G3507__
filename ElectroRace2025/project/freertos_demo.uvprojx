# Keil uVision project freertos_demo.uvprojx, settings and files
target freertos_demo (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos_demo +hex
  BeforeMake: cmd.exe /C "$P../tools/syscfg.bat '$P' blink_led.syscfg"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\project;..\source;..\source\third_party\CMSIS\Core\Include;..\kernel\freertos\Source\include;..\kernel\freertos\Source\portable\GCC\ARM_CM0;..\kernel\freertos\builds\LP_MSPM0G3507\release;..\application\app;..\application\app\fusion;..\application\app\communication;..\application\hardware\drivers;..\application\hardware\bsp;..\application\fonts;..\application\include;..\application\math;..\application\user;..\application\utils
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: ../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a ../kernel/freertos/builds/LP_MSPM0G3507/release/keil/Objects/freertos_builds_LP_MSPM0G3507_release_keil.lib
  group include
    ../application/include/: global_config.h common_include.h
  group user
    ../application/user/: main.c
  group project
    ./: ti_msp_dl_config.c startup_mspm0g350x_uvision.s freertos_demo.syscfg
  group app
    ../application/app/: gray_detection.c motor_controller.c
  group app/communication
    ../application/app/communication/: embedfire_protocol_receive.c embedfire_protocol_send.c serialplot_protocol.c
  group app/fusion
    ../application/app/fusion/: FusionAhrs.c FusionCompass.c FusionOffset.c
  group utils
    ../application/utils/: delay.c log.c
  group hardware/drivers
    ../application/hardware/drivers/: eeprom.c encoder.c icm20608.c oled.c pca9555.c w25qxx.c motor_l298n.c motor_tb6612.c
  group hardware/bsp
    ../application/hardware/bsp/: hardware_i2c.c software_i2c.c uart_driver.c spi.c
  group math
    ../application/math/: filter.c sensor.c fast_math.c
  group fonts
    ../application/fonts/: oled_data.c
  group readme
    ../../: README.md
